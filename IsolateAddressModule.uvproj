# Keil uVision project IsolateAddressModule.uvproj, settings and files
target Target (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 电源隔离型单RS485总线地址模块 +hex
  c flags: Optimize=8 SizeSpeed=1
  group system
    ./: STARTUP.A51 main.c system_init.c variable.c
  group task
    ./task/uart/: uart_task.c
    ./task/adc/: adc_task.c
  group driver
    ./driver/flash/: flash_drv.c
    ./driver/timer/: timer_drv.c
    ./driver/uart/: uart_drv.c
    ./driver/adc/: adc_drv.c
